COMPATIBLE_HOST:ti-j72xx = "${HOST_SYS}"
COMPATIBLE_MACHINE = "^$"
COMPATIBLE_MACHINE:ti-j72xx = "ti-j72xx"
