require linux-yocto-ti-j72xx.inc

KBRANCH_ti-j72xx  = "v5.4/standard/ti-j72x"

LINUX_VERSION_ti-j72xx ?= "5.4.x"
