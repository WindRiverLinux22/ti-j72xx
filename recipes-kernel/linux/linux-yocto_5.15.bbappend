require linux-yocto-ti-j72xx.inc

KBRANCH:ti-j72xx  = "v5.15/standard/ti-sdk-5.10/ti-j72xx"

LINUX_VERSION:ti-j72xx ?= "5.15.x"
