COMPATIBLE_MACHINE:ti-j72xx = "ti-j72xx"
